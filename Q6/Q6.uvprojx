# Keil uVision project Q6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAM3X4C Microchip
  pack: Atmel.SAM3X_DFP.1.0.50
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20080000,0x00008000) IROM(0x00080000,0x00020000) IROM2(0xA0000,0x00020000) IROM3(0x00100000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Q6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT5: ROM 0xa0000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20080000 size 0x8000
